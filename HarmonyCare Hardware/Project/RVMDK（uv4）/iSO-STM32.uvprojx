# Keil uVision project iSO-STM32.uvprojx, settings and files
target 代码模板 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 10_fianlly +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\SysTick;..\..\User\usart;..\..\User\ds18b20;..\..\User\Key;..\..\User\beep;..\..\User\lcd;..\..\User\bsp;..\..\bsp;..\..\User\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_usart.c
  group USER
    ../../User/: main.c time.c bsp.c exti.c bsp_ili9341_lcd.c fonts.c bsp_spi_flash.c bsp_i2c.c mpu6050.c bsp_usart.c algorithm.c myiic.c MAX30102.c sys.c other.c usart.c onenet.c MqttKit.c esp8266.c Common.h usart.h onenet.h MqttKit.h esp8266.h
    ../../User/SysTick/: delay.c
